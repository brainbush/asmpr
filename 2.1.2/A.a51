		ORG 0000
		MOV R0,#30H
		MOV R3,#10H
LP1:	MOV A,41H
		ADD A,@R0
		MOV 41H,A
		MOV A,40H
		ADDC A,#00H
		MOV 40H,A
		INC R0
		DJNZ R3,LP1
;----------------------------L41H,H40H
		MOV R0,#00
LP2:	MOV	A,40H
		JZ	LP3
		MOV	A,41H
		SUBB A,#16
		MOV 41H,A
		MOV A,40H
		SUBB A,#00H
		MOV 40H,A
		INC R0
		JNZ	LP2
LP3:	MOV A,41H
		SUBB	A,#16
		MOV 41H,A
		INC R0
		ANL	A,#11110000B
		JNZ LP3
		MOV A,41H
		JNB ACC.3,LP4
		INC R0
LP4:	MOV 40H,R0
		MOV 41H,#00
		END