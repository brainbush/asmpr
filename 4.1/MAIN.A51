		ORG 0000
LP:		SETB C
		MOV R1,#0XFE
		MOV R2,#0XFF
		MOV R3,#12
LP1:		MOV P1,R1
		MOV P3,R2
		
		MOV A,R1
		RLC A
		MOV R1,A
		
		MOV A,R2
		RLC A
		MOV R2,A
		ACALL DELAY400MS
		DJNZ R3,LP1
		JMP LP
DELAY400MS:			;@12.000MHz
		PUSH 30H
		PUSH 31H
		PUSH 32H
		MOV 30H,#4
		MOV 31H,#11
		MOV 32H,#38
NEXT3:
		DJNZ 32H,NEXT3
		DJNZ 31H,NEXT3
		DJNZ 30H,NEXT3
		POP 32H
		POP 31H
		POP 30H
		RET

	 END
